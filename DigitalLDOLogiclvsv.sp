$ Spice netlist generated by v2lvs
$ v2016.4_38.25    Tue Jan 3 14:53:59 PST 2017
.INCLUDE "/home/ff/eecs151/fa24/pdk/sky130_scl_9T_0.0.5/cdl/sky130_scl_9T.cdl"
*.BUSDELIMITER [

.SUBCKT DigitalLDOLogic clk rst comp_in out[31] out[30] out[29] out[28] out[27]
+ out[26] out[25] out[24] out[23] out[22] out[21] out[20] out[19] out[18]
+ out[17] out[16] out[15] out[14] out[13] out[12] out[11] out[10] out[9] out[8]
+ out[7] out[6] out[5] out[4] out[3] out[2] out[1] out[0]
XFE_PHC52_rst rst FE_PHN52_rst VDD VSS CLKBUFX2
XFE_PHC51_rst rst FE_PHN51_rst VDD VSS DLY1X1
XFE_PHC50_rst FE_PHN52_rst FE_PHN50_rst VDD VSS DLY1X1
XFE_PHC49_comp_in comp_in FE_PHN49_comp_in VDD VSS BUFX4
XFE_PHC48_rst rst FE_PHN48_rst VDD VSS CLKBUFX2
XFE_OFC53_out_17 FE_OFN14_out_17 out[17] VDD VSS BUFX16
XFE_OFC52_out_23 FE_OFN52_out_23 out[23] VDD VSS BUFX16
XFE_OFC51_out_25 FE_OFN51_out_25 out[25] VDD VSS BUFX16
XFE_OFC50_out_26 FE_OFN50_out_26 out[26] VDD VSS BUFX16
XFE_OFC49_out_27 FE_OFN49_out_27 out[27] VDD VSS BUFX16
XFE_OFC48_out_30 FE_OFN1_out_30 out[30] VDD VSS BUFX16
XFE_OFC47_out_24 FE_OFN7_out_24 out[24] VDD VSS BUFX16
XFE_OFC46_out_16 FE_OFN15_out_16 out[16] VDD VSS BUFX16
XFE_OFC45_out_18 FE_OFN13_out_18 out[18] VDD VSS BUFX16
XFE_OFC44_out_25 FE_OFN6_out_25 FE_OFN51_out_25 VDD VSS BUFX4
XFE_OFC43_out_28 FE_OFN3_out_28 out[28] VDD VSS BUFX16
XFE_OFC42_out_29 FE_OFN2_out_29 out[29] VDD VSS BUFX16
XCTS_ccl_a_buf_00005 clk CTS_3 VDD VSS CLKBUFX2
XCTS_ccl_a_buf_00004 clk CTS_2 VDD VSS CLKBUFX2
XCTS_ccl_a_buf_00003 clk CTS_1 VDD VSS CLKBUFX2
XCTS_ccl_a_buf_00002 clk CTS_6 VDD VSS CLKBUFX2
XCTS_ccl_a_buf_00001 clk CTS_5 VDD VSS CLKBUFX2
XFE_OFC40_out_20 FE_OFN11_out_20 out[20] VDD VSS BUFX16
XFE_OFC39_out_21 FE_OFN10_out_21 out[21] VDD VSS BUFX16
XFE_OFC38_out_22 FE_OFN9_out_22 out[22] VDD VSS BUFX16
XFE_OFC37_out_23 FE_OFN8_out_23 FE_OFN52_out_23 VDD VSS BUFX4
XFE_OFC36_out_26 FE_OFN5_out_26 FE_OFN50_out_26 VDD VSS BUFX4
XFE_OFC35_out_27 FE_OFN4_out_27 FE_OFN49_out_27 VDD VSS BUFX4
XFE_OFC34_out_31 FE_OFN0_out_31 out[31] VDD VSS BUFX16
XFE_OFC33_out_19 FE_OFN12_out_19 out[19] VDD VSS BUFX16
XFE_OFC32_out_0 FE_OFN32_out_0 out[0] VDD VSS BUFX16
XFE_OFC31_out_1 FE_OFN31_out_1 out[1] VDD VSS BUFX16
XFE_OFC30_out_2 FE_OFN30_out_2 out[2] VDD VSS BUFX16
XFE_OFC29_out_3 FE_OFN29_out_3 out[3] VDD VSS BUFX16
XFE_OFC28_out_4 FE_OFN28_out_4 out[4] VDD VSS BUFX16
XFE_OFC27_out_5 FE_OFN27_out_5 out[5] VDD VSS BUFX16
XFE_OFC26_out_6 FE_OFN26_out_6 out[6] VDD VSS BUFX16
XFE_OFC25_out_7 FE_OFN25_out_7 out[7] VDD VSS BUFX16
XFE_OFC24_out_8 FE_OFN24_out_8 out[8] VDD VSS BUFX16
XFE_OFC23_out_9 FE_OFN23_out9 out[9] VDD VSS BUFX16
XFE_OFC22_out_10 FE_OFN22_out_10 out[10] VDD VSS BUFX16
XFE_OFC21_out_11 FE_OFN21_out_11 out[11] VDD VSS BUFX16
XFE_OFC20_out_12 FE_OFN20_out_12 out[12] VDD VSS BUFX16
XFE_OFC19_out_13 FE_OFN19_out_13 out[13] VDD VSS BUFX16
XFE_OFC18_out_14 FE_OFN18_out_14 out[14] VDD VSS BUFX16
XFE_OFC17_out_15 FE_OFN17_out_15 out[15] VDD VSS BUFX16
Xpass_reg[30] CTS_2 n_95 FE_OFN1_out_30 UNCONNECTED VDD VSS DFFX1
Xg525__2398 FE_PHN48_rst n_94 n_95 VDD VSS OR2X1
Xg526__5107 FE_OFN0_out_31 FE_OFN2_out_29 FE_PHN49_comp_in n_94 VDD VSS MX2X1
Xpass_reg[31] CTS_2 n_77 FE_OFN0_out_31 UNCONNECTED0 VDD VSS DFFX1
Xpass_reg[14] CTS_1 n_70 FE_OFN18_out_14 UNCONNECTED1 VDD VSS DFFX1
Xpass_reg[1] CTS_5 n_76 FE_OFN31_out_1 UNCONNECTED2 VDD VSS DFFX1
Xpass_reg[17] CTS_5 n_65 FE_OFN14_out_17 UNCONNECTED3 VDD VSS DFFX1
Xpass_reg[18] CTS_3 n_79 FE_OFN13_out_18 UNCONNECTED4 VDD VSS DFFX1
Xpass_reg[19] CTS_3 n_91 FE_OFN12_out_19 UNCONNECTED5 VDD VSS DFFX1
Xpass_reg[20] CTS_3 n_89 FE_OFN11_out_20 UNCONNECTED6 VDD VSS DFFX1
Xpass_reg[10] CTS_1 n_63 FE_OFN22_out_10 UNCONNECTED7 VDD VSS DFFX1
Xpass_reg[7] CTS_6 n_86 FE_OFN25_out_7 UNCONNECTED8 VDD VSS DFFX1
Xpass_reg[21] CTS_3 n_90 FE_OFN10_out_21 UNCONNECTED9 VDD VSS DFFX1
Xpass_reg[22] CTS_3 n_83 FE_OFN9_out_22 UNCONNECTED10 VDD VSS DFFX1
Xpass_reg[8] CTS_6 n_84 FE_OFN24_out_8 UNCONNECTED11 VDD VSS DFFX1
Xpass_reg[23] CTS_3 n_82 FE_OFN8_out_23 UNCONNECTED12 VDD VSS DFFX1
Xpass_reg[24] CTS_3 n_81 FE_OFN7_out_24 UNCONNECTED13 VDD VSS DFFX1
Xpass_reg[25] CTS_2 n_80 FE_OFN6_out_25 UNCONNECTED14 VDD VSS DFFX1
Xpass_reg[9] CTS_6 n_85 FE_OFN23_out_9 UNCONNECTED15 VDD VSS DFFX1
Xpass_reg[27] CTS_2 n_78 FE_OFN4_out_27 UNCONNECTED16 VDD VSS DFFX1
Xpass_reg[6] CTS_6 n_87 FE_OFN26_out_6 UNCONNECTED17 VDD VSS DFFX1
Xpass_reg[3] CTS_5 n_71 FE_OFN29_out_3 UNCONNECTED18 VDD VSS DFFX1
Xpass_reg[5] CTS_6 n_64 FE_OFN27_out_5 UNCONNECTED19 VDD VSS DFFX1
Xpass_reg[29] CTS_2 n_73 FE_OFN2_out_29 UNCONNECTED20 VDD VSS DFFX1
Xpass_reg[11] CTS_1 n_74 FE_OFN21_out_11 UNCONNECTED21 VDD VSS DFFX1
Xpass_reg[26] CTS_2 n_92 FE_OFN5_out_26 UNCONNECTED22 VDD VSS DFFX1
Xpass_reg[2] CTS_5 n_75 FE_OFN30_out_2 UNCONNECTED23 VDD VSS DFFX1
Xpass_reg[28] CTS_2 n_69 FE_OFN3_out_28 UNCONNECTED24 VDD VSS DFFX1
Xpass_reg[12] CTS_1 n_88 FE_OFN20_out_12 UNCONNECTED25 VDD VSS DFFX1
Xpass_reg[13] CTS_1 n_72 FE_OFN19_out_13 UNCONNECTED26 VDD VSS DFFX1
Xpass_reg[4] CTS_5 n_68 FE_OFN28_out_4 UNCONNECTED27 VDD VSS DFFX1
Xpass_reg[15] CTS_6 n_67 FE_OFN17_out_15 UNCONNECTED28 VDD VSS DFFX1
Xpass_reg[16] CTS_5 n_66 FE_OFN15_out_16 UNCONNECTED29 VDD VSS DFFX1
Xg564__6260 FE_PHN48_rst n_33 n_92 VDD VSS OR2X1
Xg559__4319 FE_PHN48_rst n_60 n_91 VDD VSS OR2X1
Xg557__8428 FE_PHN48_rst n_32 n_90 VDD VSS OR2X1
Xg560__5526 FE_PHN48_rst n_56 n_89 VDD VSS OR2X1
Xg561__6783 FE_PHN50_rst n_42 n_88 VDD VSS OR2X1
Xg562__3680 FE_PHN48_rst n_57 n_87 VDD VSS OR2X1
Xg563__1617 FE_PHN48_rst n_55 n_86 VDD VSS OR2X1
Xg558__2802 FE_PHN48_rst n_49 n_85 VDD VSS OR2X1
Xg565__1705 FE_PHN48_rst n_51 n_84 VDD VSS OR2X1
Xg566__5122 FE_PHN48_rst n_61 n_83 VDD VSS OR2X1
Xg567__8246 FE_PHN48_rst n_53 n_82 VDD VSS OR2X1
Xg568__7098 FE_PHN48_rst n_52 n_81 VDD VSS OR2X1
Xg569__6131 FE_PHN48_rst n_40 n_80 VDD VSS OR2X1
Xg572__1881 FE_PHN48_rst n_48 n_79 VDD VSS OR2X1
Xg573__5115 FE_PHN48_rst n_39 n_78 VDD VSS OR2X1
Xg588 n_62 n_77 VDD VSS CLKINVX1
Xg575__7482 FE_PHN48_rst n_50 n_76 VDD VSS OR2X1
Xg576__4733 FE_PHN48_rst n_58 n_75 VDD VSS OR2X1
Xg577__6161 FE_PHN48_rst n_44 n_74 VDD VSS OR2X1
Xg578__9315 FE_PHN48_rst n_59 n_73 VDD VSS OR2X1
Xg579__9945 FE_PHN51_rst n_41 n_72 VDD VSS OR2X1
Xg580__2883 FE_PHN48_rst n_43 n_71 VDD VSS OR2X1
Xg581__2346 FE_PHN51_rst n_46 n_70 VDD VSS OR2X1
Xg574__1666 FE_PHN48_rst n_45 n_69 VDD VSS OR2X1
Xg582__7410 FE_PHN48_rst n_37 n_68 VDD VSS OR2X1
Xg583__6417 FE_PHN48_rst n_38 n_67 VDD VSS OR2X1
Xg584__5477 FE_PHN48_rst n_36 n_66 VDD VSS OR2X1
Xg585__2398 FE_PHN48_rst n_34 n_65 VDD VSS OR2X1
Xg586__5107 FE_PHN48_rst n_35 n_64 VDD VSS OR2X1
Xg587__6260 FE_PHN48_rst n_47 n_63 VDD VSS OR2X1
Xpass_reg[0] CTS_5 n_54 FE_OFN32_out_0 UNCONNECTED30 VDD VSS DFFX1
Xg596__4319 FE_PHN49_comp_in FE_OFN1_out_30 FE_PHN48_rst n_62 VDD VSS AOI21X1
Xg598__8428 FE_OFN8_out_23 FE_OFN10_out_21 FE_PHN49_comp_in n_61 VDD VSS MX2X1
Xg591__5526 FE_OFN11_out_20 FE_OFN13_out_18 FE_PHN49_comp_in n_60 VDD VSS MX2X1
Xg592__6783 FE_OFN1_out_30 FE_OFN3_out_28 FE_PHN49_comp_in n_59 VDD VSS MX2X1
Xg593__3680 FE_OFN29_out_3 FE_OFN31_out_1 FE_PHN49_comp_in n_58 VDD VSS MX2X1
Xg594__1617 FE_OFN25_out_7 FE_OFN27_out_5 FE_PHN49_comp_in n_57 VDD VSS MX2X1
Xg595__2802 FE_OFN10_out_21 FE_OFN12_out_19 FE_PHN49_comp_in n_56 VDD VSS MX2X1
Xg597__1705 FE_OFN24_out_8 FE_OFN26_out_6 FE_PHN49_comp_in n_55 VDD VSS MX2X1
Xg590__5122 FE_PHN49_comp_in FE_PHN48_rst FE_OFN31_out_1 n_54 VDD VSS OR3X1
Xg599__8246 FE_OFN7_out_24 FE_OFN9_out_22 FE_PHN49_comp_in n_53 VDD VSS MX2X1
Xg600__7098 FE_OFN6_out_25 FE_OFN8_out_23 FE_PHN49_comp_in n_52 VDD VSS MX2X1
Xg601__6131 FE_OFN23_out_9 FE_OFN25_out_7 FE_PHN49_comp_in n_51 VDD VSS MX2X1
Xg602__1881 FE_OFN30_out_2 FE_OFN32_out_0 FE_PHN49_comp_in n_50 VDD VSS MX2X1
Xg603__5115 FE_OFN22_out_10 FE_OFN24_out_8 FE_PHN49_comp_in n_49 VDD VSS MX2X1
Xg604__7482 FE_OFN12_out_19 FE_OFN14_out_17 FE_PHN49_comp_in n_48 VDD VSS MX2X1
Xg605__4733 FE_OFN21_out_11 FE_OFN23_out_9 FE_PHN49_comp_in n_47 VDD VSS MX2X1
Xg613__6161 FE_OFN17_out_15 FE_OFN19_out_13 FE_PHN49_comp_in n_46 VDD VSS MX2X1
Xg607__9315 FE_OFN2_out_29 FE_OFN4_out_27 FE_PHN49_comp_in n_45 VDD VSS MX2X1
Xg608__9945 FE_OFN20_out_12 FE_OFN22_out_10 FE_PHN49_comp_in n_44 VDD VSS MX2X1
Xg609__2883 FE_OFN28_out_4 FE_OFN30_out_2 FE_PHN49_comp_in n_43 VDD VSS MX2X1
Xg610__2346 FE_OFN19_out_13 FE_OFN21_out_11 FE_PHN49_comp_in n_42 VDD VSS MX2X1
Xg611__1666 FE_OFN18_out_14 FE_OFN20_out_12 FE_PHN49_comp_in n_41 VDD VSS MX2X1
Xg612__7410 FE_OFN5_out_26 FE_OFN7_out_24 FE_PHN49_comp_in n_40 VDD VSS MX2X1
Xg606__6417 FE_OFN3_out_28 FE_OFN5_out_26 FE_PHN49_comp_in n_39 VDD VSS MX2X1
Xg614__5477 FE_OFN15_out_16 FE_OFN18_out_14 FE_PHN49_comp_in n_38 VDD VSS MX2X1
Xg615__2398 FE_OFN27_out_5 FE_OFN29_out_3 FE_PHN49_comp_in n_37 VDD VSS MX2X1
Xg616__5107 FE_OFN14_out_17 FE_OFN17_out_15 FE_PHN49_comp_in n_36 VDD VSS MX2X1
Xg617__6260 FE_OFN26_out_6 FE_OFN28_out_4 FE_PHN49_comp_in n_35 VDD VSS MX2X1
Xg618__4319 FE_OFN13_out_18 FE_OFN15_out_16 FE_PHN49_comp_in n_34 VDD VSS MX2X1
Xg619__8428 FE_OFN4_out_27 FE_OFN6_out_25 FE_PHN49_comp_in n_33 VDD VSS MX2X1
Xg589__5526 FE_OFN9_out_22 FE_OFN11_out_20 FE_PHN49_comp_in n_32 VDD VSS MX2X1
.ENDS
